# Keil uVision project i2c.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F8363B SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF)  XRAM(0-0x2FF) CLOCK(24000000)
  output: i2c +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
